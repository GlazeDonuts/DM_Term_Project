** grover **
*
* NI Multisim to SPICE Netlist Export
* Generated by: fitte
* Thu, Apr 08, 2021 01:40:21
*

*## Multisim Component Q42 ##*
mQ42 23 16 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q41 ##*
mQ41 2 16 23 23 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q40 ##*
mQ40 12 22 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q39 ##*
mQ39 7 22 12 12 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q38 ##*
mQ38 8 21 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q37 ##*
mQ37 3 21 8 8 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q30 ##*
mQ30 15 9 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q29 ##*
mQ29 VDD 9 15 15 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q36 ##*
mQ36 4 19 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q35 ##*
mQ35 VDD 19 4 4 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q34 ##*
mQ34 17 20 Q34_OPEN_S Q34_OPEN_S NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q33 ##*
mQ33 VDD 20 17 17 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q32 ##*
mQ32 18 13 Q32_OPEN_S Q32_OPEN_S NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q31 ##*
mQ31 VDD 13 18 18 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component VDD ##*
VDDVDD  VDD 0 dc 5

*## Multisim Component Q28 ##*
mQ28 VDD 18 20 20 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q27 ##*
mQ27 VDD 23 20 20 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q26 ##*
mQ26 Q26_OPEN_D 18 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q25 ##*
mQ25 20 23 Q25_OPEN_S Q25_OPEN_S NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q24 ##*
mQ24 VDD 15 13 13 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q23 ##*
mQ23 VDD 12 13 13 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q22 ##*
mQ22 Q22_OPEN_D 15 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q21 ##*
mQ21 13 12 Q21_OPEN_S Q21_OPEN_S NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q20 ##*
mQ20 VDD 8 9 9 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q19 ##*
mQ19 VDD 4 9 9 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q18 ##*
mQ18 5 8 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q17 ##*
mQ17 9 4 5 5 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Instrument XFG4 ##*
XFG4 0 XFG4_OPEN_2 11 XXFG4_176767384

*## Multisim Instrument XFG3 ##*
XFG3 0 XFG3_OPEN_2 7 XXFG3_176767384

*## Multisim Instrument XFG2 ##*
XFG2 0 XFG2_OPEN_2 2 XXFG2_176767384

*## Multisim Instrument XFG1 ##*
XFG1 0 XFG1_OPEN_2 3 XXFG1_176767384

*## Multisim Component Q16 ##*
mQ16 16 11 14 14 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q15 ##*
mQ15 2 11 16 16 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q14 ##*
mQ14 14 2 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q13 ##*
mQ13 VDD 2 14 14 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q12 ##*
mQ12 22 11 10 10 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q11 ##*
mQ11 7 11 22 22 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q10 ##*
mQ10 10 7 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q9 ##*
mQ9 VDD 7 10 10 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q8 ##*
mQ8 21 7 6 6 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q7 ##*
mQ7 3 7 21 21 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q6 ##*
mQ6 6 3 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q5 ##*
mQ5 VDD 3 6 6 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q4 ##*
mQ4 19 2 1 1 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q3 ##*
mQ3 3 2 19 19 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q2 ##*
mQ2 1 3 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

*## Multisim Component Q1 ##*
mQ1 VDD 3 1 1 PMOS__TRANSISTORS_VIRTUAL__1  L=0.0001  W=0.0001

.model NMOS__TRANSISTORS_VIRTUAL__1   nmos

.model PMOS__TRANSISTORS_VIRTUAL__1 pmos

.subckt XXFG1_176767384 1 2 3
vfgen_src_positive 3 2 PULSE(0 5 0 0 0 1m 2m)
vfgen_src_negative 2 1 PULSE(0 5 0 0 0 1m 2m)
.ends

.subckt XXFG2_176767384 1 2 3
vfgen_src_positive 3 2 PULSE(0 5 0 0 0 2m 4m)
vfgen_src_negative 2 1 PULSE(0 5 0 0 0 2m 4m)
.ends

.subckt XXFG3_176767384 1 2 3
vfgen_src_positive 3 2 PULSE(0 5 0 0 0 4m 8m)
vfgen_src_negative 2 1 PULSE(0 5 0 0 0 4m 8m)
.ends

.subckt XXFG4_176767384 1 2 3
vfgen_src_positive 3 2 PULSE(0 5 0 0 0 8m 16m)
vfgen_src_negative 2 1 PULSE(0 5 0 0 0 8m 16m)
.ends

.tran 1u 32m
.control
run

set color0=black
set color1=white
set color2=red
set color3=blue
set color4=green
set Xbrushwidth=2

plot v(3) v(2)+12 v(7)+24 v(11)+36 v(17)+48
.endc
.end
