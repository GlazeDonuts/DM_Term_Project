** Design2 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: fitte
* Thu, Apr 08, 2021 01:50:51
*

*## Multisim Instrument XSC1 ##*

*## Multisim Instrument XFG4 ##*
XFG4 0 XFG4_OPEN_2 in1 XXFG4_528510624

*## Multisim Instrument XFG3 ##*
XFG3 0 XFG3_OPEN_2 in3 XXFG3_528510624

*## Multisim Instrument XFG2 ##*
XFG2 0 XFG2_OPEN_2 in2 XXFG2_528510624

*## Multisim Instrument XFG1 ##*
XFG1 0 XFG1_OPEN_2 in4 XXFG1_528510624

*## Multisim Component U5 ##*
aU5  [1 2
+     3 4] dU5.Y AND2__TIL__1

xU5.Y dU5.Y out TIL_DRV__NON__1

*## Multisim Component U4 ##*
aU4  [dU4.A dU4.B] 4 XOR2__TIL__1

xU4.A in2 dU4.A TIL_RCV__NON__1

xU4.B in1 dU4.B TIL_RCV__NON__1

*## Multisim Component U3 ##*
aU3  [dU3.A dU3.B] 3 XOR2__TIL__1

xU3.A in3 dU3.A TIL_RCV__NON__1

xU3.B in1 dU3.B TIL_RCV__NON__1

*## Multisim Component U2 ##*
aU2  [dU2.A dU2.B] 2 XOR2__TIL__1

xU2.A in4 dU2.A TIL_RCV__NON__1

xU2.B in3 dU2.B TIL_RCV__NON__1

*## Multisim Component U1 ##*
aU1  [dU1.A dU1.B] 1 XOR2__TIL__1

xU1.A in4 dU1.A TIL_RCV__NON__1

xU1.B in2 dU1.B TIL_RCV__NON__1

.subckt XXFG2_528510624 1 2 3
vfgen_src_positive 3 2 dc 2.500000e+00 ac 2.500000000000000000e+00 pulse(0.000000000000000000e+00 5.000000000000000000e+00 0 1.000000000000000021e-08 1.000000000000000021e-08 2.499999900000000053e-01 5.000000000000000000e-01)
vfgen_src_negative 2 1 dc 2.500000e+00 ac 2.500000000000000000e+00 pulse(0.000000000000000000e+00 5.000000000000000000e+00 0 1.000000000000000021e-08 1.000000000000000021e-08 2.499999900000000053e-01 5.000000000000000000e-01)
.ends

.subckt XXFG1_528510624 1 2 3
vfgen_src_positive 3 2 dc 2.500000e+00 ac 2.500000000000000000e+00 pulse(0.000000000000000000e+00 5.000000000000000000e+00 0 1.000000000000000021e-08 1.000000000000000021e-08 4.999999900000000053e-01 1.000000000000000000e+00)
vfgen_src_negative 2 1 dc 2.500000e+00 ac 2.500000000000000000e+00 pulse(0.000000000000000000e+00 5.000000000000000000e+00 0 1.000000000000000021e-08 1.000000000000000021e-08 4.999999900000000053e-01 1.000000000000000000e+00)
.ends

.MODEL AND2__TIL__1 d_and ( rise_delay = 1n fall_delay = 1n)

.MODEL XOR2__TIL__1 d_xor (rise_delay = 1n fall_delay = 1n)

.SUBCKT TIL_DRV__NON__1 1 2
* TIL Driver Model  1 = D/A input, 2 = out
 aDACin1 [1] [2] aDAC
.MODEL aDAC dac_bridge (out_low= 0 out_high = 5 out_undef = 2.5)
.ENDS

.SUBCKT TIL_RCV__NON__1 1 2
* TIL Receiver Model  1 = input, 2 = A/D out
 aADCin1 [1] [2] ADC
.MODEL ADC adc_bridge (in_low= 2.5 in_high = 2.5)
.ENDS

.subckt XXFG4_528510624 1 2 3
vfgen_src_positive 3 2 dc 2.500000e+00 ac 2.500000000000000000e+00 pulse(0.000000000000000000e+00 5.000000000000000000e+00 0 1.000000000000000021e-08 1.000000000000000021e-08 6.249998999999999832e-02 1.250000000000000000e-01)
vfgen_src_negative 2 1 dc 2.500000e+00 ac 2.500000000000000000e+00 pulse(0.000000000000000000e+00 5.000000000000000000e+00 0 1.000000000000000021e-08 1.000000000000000021e-08 6.249998999999999832e-02 1.250000000000000000e-01)
.ends
.subckt XXFG3_528510624 1 2 3
vfgen_src_positive 3 2 dc 2.500000e+00 ac 2.500000000000000000e+00 pulse(0.000000000000000000e+00 5.000000000000000000e+00 0 1.000000000000000021e-08 1.000000000000000021e-08 1.249999900000000053e-01 2.500000000000000000e-01)
vfgen_src_negative 2 1 dc 2.500000e+00 ac 2.500000000000000000e+00 pulse(0.000000000000000000e+00 5.000000000000000000e+00 0 1.000000000000000021e-08 1.000000000000000021e-08 1.249999900000000053e-01 2.500000000000000000e-01)
.ends

* .subckt XXFG1_528510624 1 2 3
* vfgen_src_positive 3 2 PULSE(0 5 0 0 0 1m 2m)
* vfgen_src_negative 2 1 PULSE(0 5 0 0 0 1m 2m)
* .ends

* .subckt XXFG2_528510624 1 2 3
* vfgen_src_positive 3 2 PULSE(0 5 0 0 0 2m 4m)
* vfgen_src_negative 2 1 PULSE(0 5 0 0 0 2m 4m)
* .ends

* .subckt XXFG3_528510624 1 2 3
* vfgen_src_positive 3 2 PULSE(0 5 0 0 0 4m 8m)
* vfgen_src_negative 2 1 PULSE(0 5 0 0 0 4m 8m)
* .ends

* .subckt XXFG4_528510624 1 2 3
* vfgen_src_positive 3 2 PULSE(0 5 0 0 0 8m 16m)
* vfgen_src_negative 2 1 PULSE(0 5 0 0 0 8m 16m)
* .ends

.tran 1m 4
.control
run

set color0=white
set color1=black
set color2=red
set color3=blue
set color4=green
set color5=orange
set color6=rgb:ff/0/ff
set Xbrushwidth=2

plot v(in1) v(in2)+12 v(in3)+24 v(in4)+36 v(out)+48
.endc
.end
