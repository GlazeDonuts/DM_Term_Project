** Design2 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: fitte
* Thu, Apr 08, 2021 00:24:12
*

*## Multisim Instrument XSC1 ##*

*## Multisim Instrument XFG1 ##*
XFG1 0 XFG1_OPEN_2 1 XXFG1_176767384

*## Multisim Component A1 ##*
aA1 [A1.PinVoltage--0.1 1] 2 MultiplierA1
.model MultiplierA1 mult(
+ out_gain=1
+ out_offset=0
+ in_offset=[0 0]
+ in_gain=[1 1])

vA1.PinVoltage1--1 1 A1.PinVoltage--0.1 DC 0.0

.subckt XXFG1_176767384 1 2 3
vfgen_src_positive 3 2 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
vfgen_src_negative 2 1 dc 0.000000e+00 ac 1.000000000000000000e+01 sin(0.000000000000000000e+00 1.000000000000000000e+01 1.000000000000000000e+00 0)
.ends

.tran 10m 5
.control
run

set color0=black
set color1=white
set color2=red
set color3=blue
set color4=green
set Xbrushwidth=2

* plot v(a0)

plot v(2)
* plot v(s0) v(s1)+7 v(s2)+14 v(s3)+21 v(c3)+28
.endc
.end
